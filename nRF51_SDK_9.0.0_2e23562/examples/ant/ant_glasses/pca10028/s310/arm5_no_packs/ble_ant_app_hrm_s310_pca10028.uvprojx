# Keil uVision project ble_ant_app_hrm_s310_pca10028.uvprojx, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: BSP_MAIN ANT_STACK_SUPPORT_REQD BLE_STACK_SUPPORT_REQD BOARD_PCA10028 S310 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\bsp;..\..\..\..\..\..\components\softdevice\s310\headers;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\ant\ant_stack_config;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\..\..\components\libraries\trace;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\ant\ant_channel_config;..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm;..\..\..\..\..\..\components\ant\ant_stack_config;..\..\..\..\..\..\components\ant\ant_state_indicator;..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm\utils;..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm\pages;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm\pages\logger;..\..\..\..\..\..\components\ant\ant_profiles\ant_cad;..\..\..\..\..\..\components\ant\ant_profiles\ant_glasses
  asm define: BLE_STACK_SUPPORT_REQD ANT_STACK_SUPPORT_REQD BOARD_PCA10028 S310 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x1d000 size 0x23000
  memory RVCT9: RAM 0x20002200 size 0x5e00
  group Application
    ../../../: main.c
  group Board Support
    ../../../../../bsp/: bsp.c bsp_btn_ble.c
  group Documentation
    ../../../: license.txt
  group nRF_ANT
    ../../../../../../components/ant/ant_stack_config/: ant_stack_config.c
    ../../../../../../components/ant/ant_channel_config/: ant_channel_config.c
    ../../../../../../components/ant/ant_profiles/ant_hrm/: ant_hrm.c
    ../../../../../../components/ant/ant_profiles/ant_hrm/pages/: ant_hrm_page_0.c ant_hrm_page_1.c ant_hrm_page_2.c ant_hrm_page_3.c ant_hrm_page_4.c
    ../../../../../../components/ant/ant_state_indicator/: ant_state_indicator.c
    ../../../../../../components/ant/ant_profiles/ant_cad/: ant_cad.c
    ../../../../../../components/ant/ant_profiles/ant_glasses/: ant_glasses.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/pstorage/: pstorage.c
    ../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../components/libraries/uart/: retarget.c
    ../../../../../../components/libraries/sensorsim/: sensorsim.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s310/doc/: s310_nrf51822_3.0.0_licence_agreement.txt
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: s310_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD ANT_STACK_SUPPORT_REQD ANT_CONFIG_CHANNEL_USED=1>ant_stack_config ANT_CONFIG_ENC_CHANNEL_USED=0>ant_stack_config ANT_CONFIG_BURST_QUEUE_SIZE=128>ant_stack_config
  c misc: --c99
  c include: ..\..\..\config
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 4.2.0, Device:Startup 8.0.3
