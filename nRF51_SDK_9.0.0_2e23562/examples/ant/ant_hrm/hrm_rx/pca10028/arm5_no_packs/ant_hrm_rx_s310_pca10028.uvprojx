# Keil uVision project ant_hrm_rx_s310_pca10028.uvprojx, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: ANT_STACK_SUPPORT_REQD ENABLE_DEBUG_LOG_SUPPORT TRACE_HRM_GENERAL_ENABLE TRACE_HRM_PAGE_0_ENABLE TRACE_HRM_PAGE_1_ENABLE TRACE_HRM_PAGE_2_ENABLE TRACE_HRM_PAGE_3_ENABLE TRACE_HRM_PAGE_4_ENABLE S310 BOARD_PCA10028 SWI_DISABLE0 NRF51 SOFTDEVICE_PRESENT
  c misc: --c99
  c include: ..\..\config;..\..\..\..\..\..\components\softdevice\s210\headers;..\..\..\..\..\bsp;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\ant\ant_state_indicator;..\..\..\..\..\..\components\libraries\trace;..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm;..\..\..\..\..\..\components\ant\ant_stack_config;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\ant\ant_channel_config;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm\pages;..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm\pages\logger;..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm\utils
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1d000 size 0x23000
  memory RVCT9: RAM 0x20002200 size 0x5e00
  group Application
    ../../: main.c
  group Board Support
    ../../../../../bsp/: bsp.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_ANT
    ../../../../../../components/ant/ant_channel_config/: ant_channel_config.c
    ../../../../../../components/ant/ant_profiles/ant_hrm/: ant_hrm.c
    ../../../../../../components/ant/ant_profiles/ant_hrm/pages/: ant_hrm_page_0.c ant_hrm_page_1.c ant_hrm_page_2.c ant_hrm_page_3.c ant_hrm_page_4.c
    ../../../../../../components/ant/ant_stack_config/: ant_stack_config.c
    ../../../../../../components/ant/ant_state_indicator/: ant_state_indicator.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../components/libraries/uart/: retarget.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s210/doc/: s210_nrf51422_5.0.0_licence_agreement.txt
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: s210_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c define: ANT_STACK_SUPPORT_REQD ENABLE_DEBUG_LOG_SUPPORT TRACE_HRM_GENERAL_ENABLE TRACE_HRM_PAGE_0_ENABLE TRACE_HRM_PAGE_1_ENABLE TRACE_HRM_PAGE_2_ENABLE TRACE_HRM_PAGE_3_ENABLE TRACE_HRM_PAGE_4_ENABLE ANT_CONFIG_CHANNEL_USED=1>ant_stack_config ANT_CONFIG_ENC_CHANNEL_USED=0>ant_stack_config ANT_CONFIG_BURST_QUEUE_SIZE=128>ant_stack_config
  c misc: --c99
  c include: ..\..\config
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 4.2.0, Device:Startup 8.0.3
